# Keil uVision project STC32G_OTA.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G_OTA +hex
  link misc: CLASSES(CODE(0xFF4000-0xFFFFFF), XDATA(0x1000-0x2EFF), EDATA(0x0-0xFFF), HDATA(0x0-0xFFF), NCONST(0xF000-0xFFFF), HCONST(0xFF4200-0xFFFFFF), ECODE(0xFF4200-0xFFFFFF)) NOOVERLAY
  group Source Group 1
    ../../COMMON/: crc32.c log.c param.c ringbuf.c
    ../../BSP/: bsp_clock.c bsp_gpio.c bsp_timer.c bsp_uart.c bsp_wdt.c flash_iap.c
    ../../OTA/: ota_partition.c ota_fsm.c
    ../../DRV/: uart_at.c http_ota.c uart2_data.c
    ../../APP/: app_mqtt.c app_main.c
