# Keil uVision project Bootloader.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Bootloader +hex
  link misc: CLASSES(XDATA(0x1000-0x2EFF), EDATA(0x0-0xFFF), HDATA(0x0-0xFFF), NCONST(0xE000-0xEFFF), HCONST(0xFF0100-0xFFFFFF), ECODE(0xFF0100-0xFFFFFF)) NOOVERLAY
  group Source Group 1
    ../../BSP/: bsp_clock.c bsp_gpio.c bsp_timer.c bsp_uart.c bsp_wdt.c flash_iap.c
    ../../COMMON/: crc32.c log.c param.c ringbuf.c
    ../../OTA/: ota_jump.c ota_partition.c ota_verify.c
    ./: boot_main.c
